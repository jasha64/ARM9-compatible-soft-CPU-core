# Keil uVision project DHRY.uvproj, settings and files
target AT91R40008 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2104 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: DHRY
  AfterMake: C:\Keil_v5\ARM\ARMCC\BIN\fromelf.exe --bin -o ./obj/DHRY.bin ./obj/DHRY.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: MSC_CLOCK
  c misc: -c -W --debug -O3 -Otime --no_inline --no_multifile -DMSC_CLOCK
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c Serial.c Time.c
  group Source Code
    ./: dhry_1.c dhry_2.c
  group Documentation
    ./: Abstract.txt
