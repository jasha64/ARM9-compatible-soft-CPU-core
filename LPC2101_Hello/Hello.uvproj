# Keil uVision project Hello.uvproj, settings and files
target LPC2100 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2101 NXP
  cpu: IRAM(0x40000000-0x400007FF) IROM(0-0x1FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Hello
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./obj/hello.bin ./obj/Hello.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x40000000 size 0x800
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c Serial.c
  group Source Code
    ./: Hello.c
  group Documentation
    ./: Abstract.txt
